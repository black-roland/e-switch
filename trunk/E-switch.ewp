# IAR project E-switch.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: LNG_RU
  ICCARM.PreInclude: ..\deleaker\mem2.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release RU (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; LNG_RU
configuration Release EN (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; LNG_EN
configuration Release TR (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; LNG_TR
configuration Release UK (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; LNG_UK
configuration Release ES (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; LNG_ES
configuration Release BG (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; LNG_BG
  group (top)
    ./: conf_loader.cpp conf_loader.h config_data.c main.cpp
    $EW_DIR$/ARM/include/: func.asm
    $EW_DIR$/ARM/deleaker/: mem2.cpp
  group Languages
    ./: languages.h
    languages/: lng_bg.h lng_en.h lng_es.h lng_ru.h lng_tr.h lng_uk.h
